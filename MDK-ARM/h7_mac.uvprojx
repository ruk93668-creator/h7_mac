# Keil uVision project h7_mac.uvprojx, settings and files
target h7_mac_CM4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x10000000-0x10047FFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M4") TZ
  output: h7_mac_CM4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H747xx,USE_PWR_LDO_SUPPLY
  c include: ../CM4/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Common\Inc;..\Board\Inc;..\CM4\Application;..\CM4\Service;..\CM4\Device\Inc;..\CM4\Platform;..\CM4\BSP;..\CM4\Framework
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: .\h7_mac_CM4_custom.sct
  link misc: --keep=g_ipc
--keep=*(.framework_init)
--keep=*(.device_export)
  group Application/MDK-ARM
    ./: startup_stm32h747xx_CM7.s startup_stm32h747xx_CM4.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_sd.c stm32h7xx_ll_sdmmc.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Common
    ../Common/Src/: ipc_application.c ipc_runtime.c ipc_core.c ipc_shared.c
    ../Common/Inc/: ipc_application.h ipc_runtime.h ipc_core.h ipc_status.h camera_config.h sys_result.h ipc_fault.h ipc_config.h framework_runtime.h framework_event.h framework_timer.h framework_list.h
  group CM4\Application
    ../CM4/Application/: app_main.c app_oled.c oled_ui.c app_oled.h
  group CM4\Framework
    ../CM4/Framework/: framework_init.c framework_init.h framework_runtime.c framework_event.c framework_timer.c
  group CM4\Service
    ../CM4/Service/: ipc_service.c ipc_service.h
  group CM4\Device
    ../CM4/Device/Src/: device.c oled_device.c
    ../CM4/Device/Inc/: device.h oled_device.h
  group CM4\Platform
    ../CM4/Platform/: ipc_platform.c platform_time.c platform_time.h
  group CM4\BSP
    ../CM4/BSP/: bsp_iic.c bsp_iic.h
  group CM7\Application
    ../CM7/Application/: app_main.c app_camera.c app_camera.h app_uvc_bridge.c app_uvc_bridge.h video_config.c video_config.h app_storage.c app_storage.h app_frame_dispatcher.c app_frame_dispatcher.h
  group CM7\Framework
    ../CM7/Framework/: framework_init.c framework_init.h framework_runtime.c framework_event.c framework_timer.c
  group CM7\Service
    ../CM7/Service/: ipc_service.c ipc_service.h usb_uvc.h usb_uvc_desc.h usb_uvc_desc.c usb_uvc_class.c usb_test_device.c usb_mode.c usb_mode.h usb_uvc_payload.c usb_uvc_payload.h jpeg_frame.c jpeg_frame.h mjpeg_avi.c mjpeg_avi.h
  group CM7\Device
    ../CM7/Device/Src/: device.c ov5640_device.c
    ../CM7/Device/Inc/: device.h ov5640_device.h
    ../CM7/Device/Components/OV5640/: ov5640.c ov5640_reg.c
  group CM7\Media
    ../CM7/Media/Src/: camera_mjpeg_fifo.c camera_capture.c
    ../CM7/Media/Inc/: camera_mjpeg_fifo.h camera_capture.h
  group CM7\Platform
    ../CM7/Platform/: ipc_platform.c platform_time.c platform_time.h usb_device.c usb_device.h usbd_conf.h sd_block.c sd_block.h storage_fs.c diskio.c storage_fs.h fatfs_diskio.h ffconf.h
  group CM7\BSP
    ../CM7/BSP/: bsp_camera.c bsp_camera.h bsp_dcmi.c bsp_dcmi.h bsp_dcmi_hal_config.h bsp_sdram.c bsp_sdram.h bsp_sdram_hal_config.h bsp_usb.c bsp_usb.h bsp_usb_hal_config.h bsp_sdmmc.c bsp_sdmmc.h bsp_sdmmc_hal_config.h bsp_sdmmc_memory.c
  group Middlewares/USB_Device_Core
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group CM7 FreeRTOS P0
    ../CM7/Platform/: platform_rtos.c platform_hal_timebase.c platform_rtos.h FreeRTOSConfig.h
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group CM7 Native Runtime
    ../Common/Src/: runtime_event.c
    ../Common/Inc/: runtime_event.h
    ../CM7/Application/: app_messages.c app_messages.h app_tasks.c app_tasks.h app_events.c app_events.h app_status.c app_status.h
    ../CM7/Application/Tasks/: camera_task.c camera_task.h usb_task.c usb_task.h control_task.c control_task.h ipc_task.c ipc_task.h storage_task.c storage_task.h
  group FatFs
    ../Middlewares/Third_Party/FatFs/: ff.c
target h7_mac_CM7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: h7_mac_CM7
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H747xx,USE_PWR_LDO_SUPPLY,APP_VIDEO_MJPEG_MODE=1
  c misc: --preinclude ../CM7/BSP/bsp_sdram_hal_config.h --preinclude ../CM7/BSP/bsp_dcmi_hal_config.h --preinclude ../CM7/BSP/bsp_usb_hal_config.h --preinclude ../CM7/BSP/bsp_sdmmc_hal_config.h
  c include: ../CM7/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Common\Inc;..\Board\Inc;..\CM7\Application;..\CM7\Service;..\CM7\Device\Inc;..\CM7\Media\Inc;..\CM7\Platform;..\CM7\BSP;..\CM7\Framework;..\CM7\Device\Components\OV5640;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Middlewares/Third_Party/FatFs
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\h7_mac_CM7_custom.sct
  link misc: as above
  group added to the first target's files
    ../CM7/Application/: app_camera_lifecycle.c app_camera_lifecycle_replay.c app_camera_qualification.c app_usb.c app_usb.h
    ../CM7/Platform/: platform_sync.c
    ../CM7/Service/: usb_msc_bot.c usb_msc_class.c usb_msc_desc.c usb_msc_ram.c usb_msc_scsi.c usb_msc_sd.c usb_msc_storage.c
software components: CMSIS:CORE 4.3.0
