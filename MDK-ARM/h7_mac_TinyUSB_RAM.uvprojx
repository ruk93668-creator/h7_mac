# Keil uVision project h7_mac_TinyUSB_RAM.uvprojx, settings and files
target TinyUSB_RAM_CM7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: h7_mac_CM7_TinyUSB_RAM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H747xx,USE_PWR_LDO_SUPPLY,TINYUSB_RAM_EXPERIMENT=1
  c include: ../CM7/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Common\Inc;..\Board\Inc;..\CM7\Application;..\CM7\Service;..\CM7\Device\Inc;..\CM7\Media\Inc;..\CM7\Platform;..\CM7\BSP;..\CM7\Framework;..\CM7\Device\Components\OV5640;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Middlewares/Third_Party/FatFs;../CM7/TinyUSB;../ThirdParty/tinyusb/src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: ./tinyusb_ram_CM7.sct
  group Isolated TinyUSB RAM CM7
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_sd.c stm32h7xx_ll_sdmmc.c
    ./: startup_stm32h747xx_CM7.s
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
    ../CM7/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../CM7/Platform/: platform_rtos.c platform_hal_timebase.c platform_sync.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../CM7/Application/Tasks/: usb_task.c
    ../CM7/Service/: usb_msc_ram.c
    ../CM7/TinyUSB/: tinyusb_experiment.c tinyusb_ram.c usb_descriptors.c
    ../ThirdParty/tinyusb/src/: tusb.c
    ../ThirdParty/tinyusb/src/common/: tusb_fifo.c
    ../ThirdParty/tinyusb/src/device/: usbd.c
    ../ThirdParty/tinyusb/src/class/msc/: msc_device.c
    ../ThirdParty/tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_common.c
software components: CMSIS:CORE 4.3.0
