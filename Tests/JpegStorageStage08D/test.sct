LR_CODE 0x08000000 0x00100000 {
 ER_CODE 0x08000000 0x00100000 { .ANY (+RO) }
 RW_DATA 0x20000000 0x00020000 { .ANY (+RW +ZI) }
}
