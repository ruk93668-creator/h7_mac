LR_ROM 0x08000000 0x00100000 { ER_ROM 0x08000000 { .ANY (+RO) } RW_DMA 0x24000000 UNINIT 0x8000 { *(.sdmmc_dma) } RW_RAM 0x20000000 0x00040000 { .ANY (+RW +ZI) } }
