LR_ROM 0x08000000 0x100000
{
 ER_ROM 0x08000000 { .ANY (+RO) }
 RW_ACCEPT 0x68080000 UNINIT 0x50000 { .ANY1 (.fatfs_acceptance) }
 RW_RAM 0x20000000 0x20000 { .ANY (+RW +ZI) }
}
