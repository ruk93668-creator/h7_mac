LR_ROM 0x08000000 0x00100000 { ER_ROM 0x08000000 { .ANY (+RO) } RW_RAM 0x20000000 0x00040000 { .ANY (+RW +ZI) } }
