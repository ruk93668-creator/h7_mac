LR_ROM 0x08000000 0x00100000
{
    ER_ROM 0x08000000 0x00100000 { .ANY (+RO) }
    RW_SHARED 0x38000000 UNINIT 0x00001000 { *(.shared) }
    RW_RAM 0x20000000 0x00020000 { .ANY (+RW +ZI) }
}
