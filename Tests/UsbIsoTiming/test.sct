LR_ROM 0x08000000 0x100000 { ER_ROM 0x08000000 { .ANY (+RO) } RW_TRACE 0x24020000 UNINIT 0x8000 { .ANY1 (.usb_iso_timing) } RW_RAM 0x20000000 0x20000 { .ANY (+RW +ZI) } }
