LR_TEST 0x08000000 0x00100000
{
 ER_TEST 0x08000000 { .ANY (+RO) }
 ER_FW_INIT +0 ALIGN 4 { *(.framework_init) }
 RW_TEST 0x20000000 0x00040000 { .ANY (+RW +ZI) }
}
